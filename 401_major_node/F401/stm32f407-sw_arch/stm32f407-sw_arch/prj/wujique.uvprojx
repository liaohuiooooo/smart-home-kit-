# Keil uVision project wujique.uvprojx, settings and files
target wujique (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wujique +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -bin -o H:\wujique\prog\stm32f407\prj\Objects\wujique.bin H:\wujique\prog\stm32f407\prj\Objects\wujique.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\app;..\StLib\core;..\StLib\STM32F4xx_StdPeriph_Driver\inc;..\mcu_dev;..\board_dev;..\Utilities\font;..\Utilities\tslib\src;..\Utilities\tslib\tests;..\app\usb\inc;..\StLib\STM32_USB_OTG_Driver\inc;..\StLib\STM32_USB_HOST_Library\Core\inc;..\StLib\STM32_USB_HOST_Library\Class\MSC\inc;..\StLib\STM32_USB_Device_Library\Core\inc;..\StLib\STM32_USB_Device_Library\Class\msc\inc;..\Utilities\fat_fs\src;..\app\eth\inc;..\StLib\STM32F4x7_ETH_Driver\inc;..\Utilities\lwip-1.4.1\port\STM32F4x7\Standalone;..\Utilities\lwip-1.4.1\src\include\ipv4;..\Utilities\lwip-1.4.1\src\include;..\Utilities\lwip-1.4.1\src\include\netif;..\Utilities\lwip-1.4.1\port\STM32F4x7;..\Utilities\lwip-1.4.1\src\include\lwip;..\Utilities\alloc;..\function;..\Utilities\FreeRTOS\Source\include;..\Utilities\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Utilities\cmd;..\Utilities\spiffs-0.3.7\src;..\Utilities\littlefs-master;..\board_dev\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\wujique.sct
  link misc: --keep=strcmd_*
  group app
    ../app/: main.c stm32f4xx_it.c system_stm32f4xx.c wujique_log.c wujique_stm407.c wujique_sysconf.c sys_spiffs.c sys_littlefs.c
  group STM32F4xx_StdPeriph_Driver
    ../StLib/core/: startup_stm32f40_41xxx.s
    ../StLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mcu_dev
    ../mcu_dev/: mcu_uart.c mcu_timer.c stm324xg_eval_fsmc_sram.c mcu_i2c.c mcu_dac.c mcu_spi.c mcu_sdio.c mcu_i2s.c mcu_adc.c mcu_dcmi.c mcu_can.c mcu_rtc.c mcu_bsp_stm32.c
  group board_dev
    ../board_dev/: dev_key.c dev_buzzer.c dev_touchkey.c dev_tea5767.c dev_dacsound.c dev_spiflash.c stm324xg_eval_sdio_sd.c dev_wm8978.c dev_touchscreen.c dev_xpt2046.c camera_api.c dcmi_ov2640.c dcmi_ov9655.c dev_rs485.c dev_keypad.c dev_rf24l01.c dev_esp8266.c dev_htu21d.c
    ../board_dev/lcd/: dev_IL91874.c dev_ILI9325.c dev_ILI9341.c dev_lcd.c dev_lcdbus.c dev_st7735r.c dev_st7789.c dev_str7565.c dev_IL3820.c
  group other
    ../Utilities/: audio_sample.c
    ../Utilities/font/: font_8x8.c font_8x16.c font.c font_6x12.c
    ../Utilities/alloc/: alloc.c
  group tslib
    ../Utilities/tslib/src/: ts_attach.c ts_close.c ts_config.c ts_fd.c ts_load_module.c ts_open.c ts_parse_vars.c ts_read.c ts_read_raw.c
    ../Utilities/tslib/plugins/: dejitter.c linear.c pthres.c stm32-raw.c variance.c
    ../Utilities/tslib/tests/: testutils.c ts_calibrate.c
  group usb_app
    ../app/usb/src/: dual_func_demo.c usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbh_msc_usr.c
  group usb_otg_driver
    ../StLib/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_hcd.c usb_dcd_int.c usb_dcd.c usb_core.c
  group usb_host_core
    ../StLib/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group usb_host_class_msc
    ../StLib/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group usb_device_core
    ../StLib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb_device_class_msc
    ../StLib/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group fatfs
    ../Utilities/fat_fs/src/: diskio.c ff.c
    ../Utilities/fat_fs/src/option/: cc936.c syscall.c
  group eth_app
    ../app/eth/src/: eth_app.c netconf.c stm32f4x7_eth_bsp.c tcp_echoserver.c
  group STM32F4x7_ETH_Driver
    ../StLib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group lwip
    ../Utilities/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Utilities/lwip-1.4.1/src/netif/: etharp.c
    ../Utilities/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
  group fun
    ../function/: soundplay.c emenu.c emenu_test.c list.c maths.c
  group freertos
    ../Utilities/FreeRTOS/Source/: frtos_croutine.c frtos_event_groups.c frtos_list.c frtos_queue.c frtos_stream_buffer.c frtos_tasks.c frtos_timers.c
    ../Utilities/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group cmd
    ../Utilities/cmd/: cmd.c cmd_nvedit.c cmd_sys.c commnad.c console.c env.c cmd_spiffs.c
  group spiffs
    ../Utilities/spiffs-0.3.7/src/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
  group littlefs
    ../Utilities/littlefs-master/: lfs.c lfs_util.c
